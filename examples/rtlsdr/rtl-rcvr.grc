<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtlsdr_rcvr_example</value></param>
<param><key>author</key><value>WD8RDE</value></param>
<param><key>category</key><value>[Core]/WD8RDE/rtlsdr</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>RTLSDR Receiver Example</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_out_device_param</value></param>
<param><key>label</key><value>Audio Output Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>audio_output</key>
<param><key>id</key><value>audio_output_0</value></param>
<param><key>af_gain</key><value>audio_output_gain</value></param>
<param><key>audio_output_device</key><value>audio_out_device_param</value></param>
<param><key>audio_samp_rate_param</key><value>audio_samp_rate_param</value></param>
<param><key>iq_samp_rate_param</key><value>iq_sample_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_output_gain</value></param>
<param><key>label</key><value>Audio Output Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_samp_rate_param</value></param>
<param><key>label</key><value>Audio Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth_hi_param</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth_low_param</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>baseband_out_pad_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>baseband_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_param</value></param>
<param><key>label</key><value>Frequency offset from LO Frequency</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>iq_rxvr</key>
<param><key>id</key><value>iq_rxvr_0</value></param>
<param><key>width</key><value>bandwidth_hi_param</value></param>
<param><key>agc_decay</key><value>.000050</value></param>
<param><key>freq_offset</key><value>freq_offset_param</value></param>
<param><key>low_cut</key><value>bandwidth_low_param</value></param>
<param><key>modulation_mode</key><value>mod_mode_param</value></param>
<param><key>samp_rate_0</key><value>iq_sample_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_sample_rate_param</value></param>
<param><key>label</key><value>Sample rate for IQ streams</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_freq_param</value></param>
<param><key>label</key><value>Local Osc Freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_mode_param</value></param>
<param><key>label</key><value>Modulation Mode</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"LSB"</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>audio_out</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>demod_in</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain_param</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>lo_freq_param</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>rf_gain_param</value></param>
<param><key>args</key><value></value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>iq_sample_rate_param</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>audio_output_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_output_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>audio_output_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>audio_output_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>baseband_out_pad_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>iq_rxvr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
