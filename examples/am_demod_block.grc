<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_demod_block</value></param>
<param><key>author</key><value>WD8RDE</value></param>
<param><key>category</key><value>[Core]/WD8RDE</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AM Demodulator</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>band_width_param</value></param>
<param><key>audio_stop</key><value>float(band_width_param+500)</value></param>
<param><key>chan_rate</key><value>iq_sampl_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band_width_param</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2700</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_sampl_rate_param</value></param>
<param><key>label</key><value>IQ Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_demod_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>demod_out</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_iq_source</value></param>
<param><key>label</key><value>iq_in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>pad_demod_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>pad_demod_out</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_iq_source</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
