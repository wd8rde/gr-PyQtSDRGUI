<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>genesis_g59_xcvr</value></param>
<param><key>author</key><value>WD8RDE</value></param>
<param><key>category</key><value>[Core]/WD8RDE/genesis</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Genesis G59 Transceiver</value></param>
</block>
<block>
<key>audio_iq_rx_frontend</key>
<param><key>id</key><value>audio_iq_rx_frontend_0</value></param>
<param><key>rf_gain_param</key><value>rf_gain_param</value></param>
<param><key>audio_iq_rx_device</key><value>input_iq_audio_device_param</value></param>
<param><key>audio_iq_samp_rate</key><value>iq_sample_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_out_device_param</value></param>
<param><key>label</key><value>Audio Output Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>audio_output</key>
<param><key>id</key><value>audio_output_0</value></param>
<param><key>af_gain</key><value>audio_output_gain</value></param>
<param><key>audio_output_device</key><value>audio_out_device_param</value></param>
<param><key>audio_samp_rate_param</key><value>audio_samp_rate_param</value></param>
<param><key>iq_samp_rate_param</key><value>iq_sample_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_output_gain</value></param>
<param><key>label</key><value>Audio Output Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_preamp_param</value></param>
<param><key>label</key><value>Audio Preamp on/off</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_samp_rate_param</value></param>
<param><key>label</key><value>Audio Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>band_param</value></param>
<param><key>label</key><value>Band Selector</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth_hi_param</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth_low_param</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>baseband_out_pad_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>baseband_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_param</value></param>
<param><key>label</key><value>Frequency offset from LO Frequency</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>genesis_g59</key>
<param><key>id</key><value>genesis_g59_0</value></param>
<param><key>attenuation</key><value>rf_atten_param</value></param>
<param><key>audio_preamp</key><value>audio_preamp_param</value></param>
<param><key>band_filter</key><value>band_param</value></param>
<param><key>dummy_usb</key><value>False</value></param>
<param><key>lo_freq</key><value>lo_freq_param</value></param>
<param><key>rf_preamp</key><value>rf_preamp_param</value></param>
<param><key>tx</key><value>False</value></param>
<param><key>transverter</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_iq_audio_device_param</value></param>
<param><key>label</key><value>Input IQ Audio Device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>iq_rxvr</key>
<param><key>id</key><value>iq_rxvr_0</value></param>
<param><key>width</key><value>bandwidth_hi_param</value></param>
<param><key>agc_decay</key><value>.000050</value></param>
<param><key>freq_offset</key><value>freq_offset_param</value></param>
<param><key>low_cut</key><value>bandwidth_low_param</value></param>
<param><key>modulation_mode</key><value>mod_mode_param</value></param>
<param><key>samp_rate_0</key><value>iq_sample_rate_param</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_sample_rate_param</value></param>
<param><key>label</key><value>Sample rate for IQ streams</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_freq_param</value></param>
<param><key>label</key><value>Local Osc Freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_mode_param</value></param>
<param><key>label</key><value>Modulation Mode</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"LSB"</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>audio_out</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>demod_in</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_atten_param</value></param>
<param><key>label</key><value>Rf Attenuation On/Off</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain_param</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_preamp_param</value></param>
<param><key>label</key><value>RF Preamp on/off</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>audio_iq_rx_frontend_0</source_block_id><sink_block_id>baseband_out_pad_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_iq_rx_frontend_0</source_block_id><sink_block_id>iq_rxvr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_output_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_output_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>audio_output_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_rxvr_0</source_block_id><sink_block_id>audio_output_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
</flow_graph>
