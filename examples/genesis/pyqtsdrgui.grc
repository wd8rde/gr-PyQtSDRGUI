<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>value</key><value>(variable_volume_percent_0/100.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_output_device</value></param>
<param><key>value</key><value>"pulse"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset_0</value></param>
<param><key>value</key><value>variable_gui_on_vfo_freq_0 - variable_on_lo_freq_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iq_input_device</value></param>
<param><key>value</key><value>"plughw:SB,0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>iq_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain_0</value></param>
<param><key>value</key><value>(variable_rf_gain_percent0/100.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>19200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_audio_preamp_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_drive_percent_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_gui_bandwidth_high_0</value></param>
<param><key>value</key><value>2700</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_gui_bandwidth_low_0</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_gui_modulation_0</value></param>
<param><key>value</key><value>"LSB"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_gui_on_band_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_gui_on_vfo_freq_0</value></param>
<param><key>value</key><value>10001000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_mic_percent_0</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_mute_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_on_lo_freq_0</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>variable_gui_modulation_0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>variable_volume_percent_0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Volume percent</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>variable_rf_gain_percent0</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>RF Percent</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_0</value></param>
<param><key>value</key><value>freq_offset_0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Freq offset</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1_1</value></param>
<param><key>value</key><value>variable_rf_gain_percent0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>LO Freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_rf_atten_0</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_rf_gain_percent0</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_rf_preamp_0</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_volume_percent_0</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_vox_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>PyQtSDRGUI</key>
<param><key>id</key><value>PyQtSDRGUI_0</value></param>
<param><key>audiopreampchangevar</key><value>variable_audio_preamp_0</value></param>
<param><key>bandchangevar</key><value>variable_gui_on_band_0</value></param>
<param><key>band_id</key><value>1</value></param>
<param><key>bandwidth_high_changevar</key><value>variable_gui_bandwidth_high_0</value></param>
<param><key>bandwidth_high</key><value>2700</value></param>
<param><key>bandwidth_low_changevar</key><value>variable_gui_bandwidth_low_0</value></param>
<param><key>bandwidth_low</key><value>200</value></param>
<param><key>drive_changevar</key><value>variable_drive_percent_0</value></param>
<param><key>drive</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>itu_region</key><value>'itu-region2'</value></param>
<param><key>lochangevar</key><value>variable_on_lo_freq_0</value></param>
<param><key>lo_freq</key><value>7000000</value></param>
<param><key>mic_changevar</key><value>variable_mic_percent_0</value></param>
<param><key>mic</key><value>60</value></param>
<param><key>modulationchangevar</key><value>variable_gui_modulation_0</value></param>
<param><key>modulation_mode</key><value>3</value></param>
<param><key>mutechangevar</key><value>variable_mute_0</value></param>
<param><key>rfattenchangevar</key><value>variable_rf_atten_0</value></param>
<param><key>rf_gain_changevar</key><value>variable_rf_gain_percent0</value></param>
<param><key>rf_gain</key><value>100</value></param>
<param><key>rfpreampchangevar</key><value>variable_rf_preamp_0</value></param>
<param><key>sample_rate</key><value>iq_samp_rate</value></param>
<param><key>vfochangevar</key><value>variable_gui_on_vfo_freq_0</value></param>
<param><key>vfo_freq</key><value>7001000</value></param>
<param><key>volumechangevar</key><value>variable_volume_percent_0</value></param>
<param><key>volume</key><value>5</value></param>
<param><key>voxchangevar</key><value>variable_vox_0</value></param>
</block>
<block>
<key>genesis_g59_xcvr</key>
<param><key>id</key><value>genesis_g59_xcvr_0</value></param>
<param><key>audio_out_device_param</key><value>audio_output_device</value></param>
<param><key>audio_output_gain</key><value>audio_gain</value></param>
<param><key>audio_preamp_param</key><value>variable_audio_preamp_0</value></param>
<param><key>audio_samp_rate_param</key><value>audio_samp_rate</value></param>
<param><key>band_param</key><value>variable_gui_on_band_0</value></param>
<param><key>freq_offset_param</key><value>freq_offset_0</value></param>
<param><key>input_iq_audio_device_param</key><value>iq_input_device</value></param>
<param><key>lo_freq_param</key><value>variable_on_lo_freq_0</value></param>
<param><key>mod_mode_param</key><value>variable_gui_modulation_0</value></param>
<param><key>rf_gain_param</key><value>rf_gain_0</value></param>
<param><key>rf_preamp_param</key><value>variable_rf_preamp_0</value></param>
<param><key>rf_atten_param</key><value>variable_rf_atten_0</value></param>
<param><key>iq_sample_rate_param</key><value>iq_samp_rate</value></param>
<param><key>bandwidth_hi_param</key><value>variable_gui_bandwidth_high_0</value></param>
<param><key>bandwidth_low_param</key><value>variable_gui_bandwidth_low_0</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>iq_samp_rate</value></param>
<param><key>fc</key><value>variable_on_lo_freq_0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>15</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>variable_gui_bandwidth_high_0 *10</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>4,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>15</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<connection><source_block_id>genesis_g59_xcvr_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>genesis_g59_xcvr_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
