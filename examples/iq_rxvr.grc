<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>iq_rxvr</value></param>
<param><key>author</key><value>WD8RDE</value></param>
<param><key>category</key><value>[Core]/WD8RDE</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>IQ Receiver</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>agc_decay</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.000050</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>demod_in_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>demod in</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>demod_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>iq_in</value></param>
<param><key>label</key><value>IQ Input</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>iq_tuner</key>
<param><key>id</key><value>iq_tuner_0</value></param>
<param><key>width</key><value>width</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>low_cut</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation_mode</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"LSB"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>ssb_demod</key>
<param><key>id</key><value>ssb_demod_0</value></param>
<param><key>width</key><value>width</value></param>
<param><key>agc_decay</key><value>.000050</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>low_cut</key><value>20</value></param>
<param><key>modulation_mode</key><value>modulation_mode</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Band Width</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2700</value></param>
</block>
<connection><source_block_id>iq_in</source_block_id><sink_block_id>iq_tuner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_tuner_0</source_block_id><sink_block_id>demod_in_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iq_tuner_0</source_block_id><sink_block_id>ssb_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ssb_demod_0</source_block_id><sink_block_id>demod_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
