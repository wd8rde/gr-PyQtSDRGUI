<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ssb_modulator</value></param>
<param><key>category</key><value>[Core]/WD8RDE</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>SSB Weaver Modulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_center</value></param>
<param><key>value</key><value>channel_width/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>3.4e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_lpf</value></param>
<param><key>value</key><value>[1.3720911056225304e-06, 1.071107249117631e-06, 7.040755463094683e-07, 2.872369861961488e-07, -1.5999307834135834e-07, -6.159121426208003e-07, -1.0575678288660129e-06, -1.4618976820202079e-06, -1.8069151792587945e-06, -2.072881898129708e-06, -2.2434035145124653e-06, -2.3063942080625566e-06, -2.254845639981795e-06, -2.087366056002793e-06, -1.8084441535393125e-06, -1.42841849992692e-06, -9.631465900383773e-07, -4.333746801421512e-07, 1.3616090654977597e-07, 7.178708756327978e-07, 1.2826316151404171e-06, 1.8012269720202312e-06, 2.245840050818515e-06, 2.591520569694694e-06, 2.8175543320685392e-06, 2.9086543236189755e-06, 2.8559143174788915e-06, 2.6574625735520385e-06, 2.318777433174546e-06, 1.8526350231695687e-06, 1.2786815659637796e-06, 6.226417781363125e-07, -8.480726876314293e-08, -8.094500003608118e-07, -1.515168492005614e-06, -2.1657247089024168e-06, -2.726600541791413e-06, -3.166805072396528e-06, -3.4605543532961747e-06, -3.5887314879801124e-06, -3.540053739925497e-06, -3.3118687952082837e-06, -2.910537887146347e-06, -2.3513671294494998e-06, -1.658085693634348e-06, -8.618755487077578e-07, 2.7149318168432e-20, 8.859187232701515e-07, 1.751888817125291e-06, 2.5537140118103707e-06, 3.249227802371024e-06, 3.8004861835361226e-06, 4.175801677774871e-06, 4.351517873146804e-06, 4.313424597057747e-06, 4.057724254380446e-06, 3.5915018088417128e-06, 2.932656343546114e-06, 2.1092746465001255e-06, 1.1584795629460132e-06, 1.2478736266530177e-07, -9.419523507858685e-07, -1.9889384930138476e-06, -2.96301050184411e-06, -3.8133268844831036e-06, -4.493989763432182e-06, -4.9664881771605e-06, -5.201832209422719e-06, -5.182248060009442e-06, -4.902358796243789e-06, -4.369762336864369e-06, -3.6049675600224873e-06, -2.6406769393361174e-06, -1.520434580015717e-06, -2.9669553214262123e-07, 9.716046633911901e-07, 2.221864406237728e-06, 3.390883193787886e-06, 4.418033768160967e-06, 5.248376055533299e-06, 5.835563570144586e-06, 6.144379312900128e-06, 6.152769856271334e-06, 5.853268248756649e-06, 5.253707058727741e-06, 4.377180175652029e-06, 3.2612329050607514e-06, 1.956307414729963e-06, 5.234977606960456e-07, -9.682810286903987e-07, -2.445581003485131e-06, -3.834014023595955e-06, -5.061973752162885e-06, -6.064296030672267e-06, -6.7856844907510094e-06, -7.183709385572001e-06, -7.231227300508181e-06, -6.9180837272142526e-06, -6.251998001971515e-06, -5.258572855382226e-06, -3.980392648372799e-06, -2.4752587250986835e-06, -8.13615827155445e-07, 9.247138450518833e-07, 2.6543375497567467e-06, 4.288461695978185e-06, 5.743218025600072e-06, 6.941942046978511e-06, 7.819173333700746e-06, 8.324175723828375e-06, 8.42380632093409e-06, 8.104535481834318e-06, 7.373547759925714e-06, 6.258811936277198e-06, 4.808108769793762e-06, 3.0870455702824984e-06, 1.1761350151573424e-06, -8.329383263117052e-07, -2.8416864097380312e-06, -4.749618710775394e-06, -6.459241376433056e-06, -7.881008059484884e-06, -8.93797096068738e-06, -9.569893336447421e-06, -9.736605534271803e-06, -9.420424248673953e-06, -8.627490387880243e-06, -7.387930509139551e-06, -5.754829544457607e-06, -3.8020255033188732e-06, -1.6208155102503952e-06, 6.842709012744308e-07, 3.0004514428583207e-06, 5.2121790758974385e-06, 7.206877853604965e-06, 8.880638233677018e-06, 1.0143590770894662e-05, 1.0924682101176586e-05, 1.1175587133038789e-05, 1.087358032236807e-05, 1.0023149116022978e-05, 8.656304999021813e-06, 6.831486643932294e-06, 4.631153387890663e-06, 2.158102915927884e-06, -4.6928943220336805e-07, -3.1227009458234534e-06, -5.6700987443036865e-06, -7.982276656548493e-06, -9.93937919702148e-06, -1.1437066859798506e-05, -1.2392028111207765e-05, -1.2746539141517133e-05, -1.2471822628867812e-05, -1.157001588580897e-05, -1.0074636520585045e-05, -8.0494819485466e-06, -5.585981853073463e-06, -2.7991354727419093e-06, 1.7781452754661586e-07, 3.1997171845432604e-06, 6.11655605098349e-06, 8.780863026913721e-06, 1.1055138202209491e-05, 1.2818905815947801e-05, 1.3975037290947512e-05, 1.445502584829228e-05, 1.4222919162421022e-05, 1.3277694051794242e-05, 1.1653921319521032e-05, 9.42066890274873e-06, 6.678649697278161e-06, 3.5557497994886944e-06, 2.0110621790081495e-07, -3.2219727472693194e-06, -6.5439230638730805e-06, -9.597290045348927e-06, -1.222512946696952e-05, -1.4289034879766405e-05, -1.5676367183914408e-05, -1.6306328689097427e-05, -1.613453969184775e-05, -1.5155882465478498e-05, -1.3405420759227127e-05, -1.0957334779959638e-05, -7.921878932393156e-06, -4.4404819163901266e-06, -6.79212178056332e-07, 3.1791037145012524e-06, 6.943726475583389e-06, 1.0425402251712512e-05, 1.34458305183216e-05, 1.5846755559323356e-05, 1.7498199667898007e-05, 1.8305418052477762e-05, 1.8214215742773376e-05, 1.7214324543601833e-05, 1.5340629033744335e-05, 1.2672181583184283e-05, 9.32896182348486e-06, 5.466570655698888e-06, 1.2690413768723374e-06, -3.059888285861234e-06, -7.306618954316946e-06, -1.1258193808316719e-05, -1.4712933989358135e-05, -1.7490687241661362e-05, -1.944216273841448e-05, -2.0456875063246116e-05, -2.0469278751988895e-05, -1.946276461239904e-05, -1.747124406392686e-05, -1.4578290574718267e-05, -1.0913742698903661e-05, -6.64795197735657e-06, -1.983939682759228e-06, 2.852226771210553e-06, 7.6223432188271545e-06, 1.208776575367665e-05, 1.6021298506530002e-05, 1.92187144421041e-05, 2.150929685740266e-05, 2.2764859750168398e-05, 2.2906828235136345e-05, 2.1910902432864532e-05, 1.9809116565738805e-05, 1.6689109543222003e-05, 1.2690607036347501e-05, 7.999254194146488e-06, 2.8380684398143785e-06, -2.543119990150444e-06, -7.87970839155605e-06, -1.2905288713227492e-05, -1.7364909581374377e-05, -2.102794860547874e-05, -2.369998583162669e-05, -2.5233048290829174e-05, -2.553366357460618e-05, -2.4568362277932465e-05, -2.236623186036013e-05, -1.9018409147975035e-05, -1.4674459634989034e-05, -9.53579456108855e-06, -3.846408617391717e-06, 2.1186572212172905e-06, 8.066555892582983e-06, 1.3700967429031152e-05, 1.873681685538031e-05, 2.291464807058219e-05, 2.601392043288797e-05, 2.7864569347002544e-05, 2.8356236725812778e-05, 2.7444617444416508e-05, 2.5154649847536348e-05, 2.1580261091003194e-05, 1.688070551608689e-05, 1.1273565178271383e-05, 5.024763595429249e-06, -1.5639967614333727e-06, -8.169738975993823e-06, -1.4464001651504077e-05, -2.0129120457568206e-05, -2.4874205337255262e-05, -2.8450016543501988e-05, -3.066196586587466e-05, -3.138060128549114e-05, -3.0548970244126394e-05, -2.8186470444779843e-05, -2.4388995370827615e-05, -1.9325219909660518e-05, -1.3229222531663254e-05, -6.38975916444906e-06, 8.63355865021731e-07, 8.175096809281968e-06, 1.518255339760799e-05, 2.1532890968956053e-05, 2.6901067030848935e-05, 3.1006387871457264e-05, 3.362712959642522e-05, 3.461236337898299e-05, 3.3890464692376554e-05, 3.147378811263479e-05, 2.7459172997623682e-05, 2.2024330974090844e-05, 1.54200733959442e-05, 7.958842616062611e-06, -8.183177858798283e-19, -8.067427188507281e-06, -1.5843706933083013e-05, -2.2938149413676e-05, -2.8988690246478654e-05, -3.368028410477564e-05, -3.676124106277712e-05, -3.8056601624703035e-05, -3.74778792320285e-05, -3.502863910398446e-05, -3.080553869949654e-05, -2.499478250683751e-05, -1.7864056644611992e-05, -9.750277968123555e-06, -1.0437665878271218e-06, 7.830474714864977e-06, 1.643344876356423e-05, 2.4333823603228666e-05, 3.1129500712268054e-05, 3.6468009056989104e-05, 4.0064711356535554e-05, 4.1717838030308485e-05, 4.131963214604184e-05, 3.8862970541231334e-05, 3.4442986361682415e-05, 2.8253718483028933e-05, 2.057973324554041e-05, 1.1783139598264825e-05, 2.28660746870446e-06, -7.446901236107806e-06, -1.6936624888330698e-05, -2.5707699023769237e-05, -3.331484549562447e-05, -3.9364917029161006e-05, -4.3537136662052944e-05, -4.5599957957165316e-05, -4.542374881566502e-05, -4.2988565837731585e-05, -3.8386515370802954e-05, -3.1818632123759016e-05, -2.3586248062201776e-05, -1.4077308151172474e-05, -3.748159315364319e-06, 6.89827584210434e-06, 1.733692261041142e-05, 2.704638427530881e-05, 3.55349293386098e-05, 4.2365318222437054e-05, 4.7177232772810385e-05, 4.970617010258138e-05, 4.9797807150753215e-05, 4.741702650790103e-05, 4.265120151103474e-05, 3.570735134417191e-05, 2.6903333491645753e-05, 1.6653457350912504e-05, 5.449036507343408e-06, -6.165055310702883e-06, -1.7616826880839653e-05, -2.8335274691926315e-05, -3.777878373512067e-05, -4.546243144432083e-05, -5.098278052173555e-05, -5.403895920608193e-05, -5.444886483019218e-05, -5.215968849370256e-05, -4.7252135118469596e-05, -3.9937993278726935e-05, -3.0551273084711283e-05, -1.9533046724973246e-05, -7.410833404719597e-06, 5.226567736826837e-06, 1.7757613022695296e-05, 2.955851778096985e-05, 4.0034225094132125e-05, 4.864836228080094e-05, 5.49505784874782e-05, 5.859998782398179e-05, 5.9383433836046606e-05, 5.7227607612730935e-05, 5.220438106334768e-05, 4.452894791029394e-05, 3.455087426118553e-05, 2.2738311599823646e-05, 9.656127076596022e-06, -4.061001163790934e-06, -1.773930671333801e-05, -3.069896047236398e-05, -4.228778925607912e-05, -5.191401214688085e-05, -5.9076362958876416e-05, -6.339007813949138e-05, -6.460740405600518e-05, -6.2631479522679e-05, -5.7522956922184676e-05, -4.949882713845e-05, -3.892346649081446e-05, -2.629225309647154e-05, -1.220847752847476e-05, 2.6453863029018976e-06, 1.7540660337544978e-05, 3.1738138204673305e-05, 4.452470238902606e-05, 5.5249056458706036e-05, 6.33547970210202e-05, 6.840917194494978e-05, 7.012601417955011e-05, 6.838160334154963e-05, 6.322276021819562e-05, 5.4866432037670165e-05, 4.369084854261018e-05, 3.021862721652724e-05, 1.5092430658114608e-05, -9.555861879562144e-07, -1.7139131159638055e-05, -3.265621853643097e-05, -4.672884097089991e-05, -5.864188278792426e-05, -6.777937232982367e-05, -7.365621422650293e-05, -7.594375347252935e-05, -7.44878634577617e-05, -6.931859388714656e-05, -6.065074558136985e-05, -4.887529939878732e-05, -3.4541932109277695e-05, -1.833352325775195e-05, -1.033721559906553e-06, 1.6510857676621526e-05, 3.34319774992764e-05, 4.888266994385049e-05, 6.207953992998227e-05, 7.234239456010982e-05, 7.912916771601886e-05, 8.206436177715659e-05, 8.095960220089182e-05, 7.582499529235065e-05, 6.687087443424389e-05, 5.449953823699616e-05, 3.92874026147183e-05, 2.1958279830869287e-05, 3.349057124069077e-06, -1.5630626876372844e-05, -3.4042761399177834e-05, -5.096722816233523e-05, -6.554771243827417e-05, -7.703489973209798e-05, -8.482490375172347e-05, -8.849076402839273e-05, -8.780568168731406e-05, -8.275635627796873e-05, -7.354602712439373e-05, -6.058671715436503e-05, -4.448100662557408e-05, -2.599422623461578e-05, -6.018156000209274e-06, 1.4471857866737992e-05, 3.4464450436644256e-05, 5.2962059271521866e-05, 6.903062603669241e-05, 8.184662874555215e-05, 9.073920227820054e-05, 9.52250265982002e-05, 9.503438195679337e-05, 9.012679947772995e-05, 8.069552131928504e-05, 6.716039206366986e-05, 5.014944326831028e-05, 3.0469889679807238e-05, 9.069990483112633e-06, -1.3006559129280504e-05, -3.467142232693732e-05, -5.484518624143675e-05, -7.251106580952182e-05, -8.676598372403532e-05, -9.686667908681557e-05, -0.00010226826998405159, -0.00010265334276482463, -9.795014193514362e-05, -8.83386965142563e-05, -7.424454088322818e-05, -5.632012471323833e-05, -3.541481783031486e-05, -1.2534786947071552e-05, 1.1205309419892728e-05, 3.463651592028327e-05, 5.659306043526158e-05, 7.597025251016021e-05, 9.177993342746049e-05, 0.00010320076398784295, 0.00010962071246467531, 0.00011066957813454792, 0.00010623990237945691, 9.649497224017978e-05, 8.18635307950899e-05, 6.302123074419796e-05, 4.085959153599106e-05, 1.6444055290776305e-05, -9.03721411305014e-06, -3.433098390814848e-05, -5.8180507039651275e-05, -7.938786438899115e-05, -9.68740350799635e-05, -0.00010973360622301698, -0.00011728156096069142, -0.00011908944725291803, -0.0001150093085016124, -0.00010518378985580057, -9.00421291589737e-05, -7.028163236100227e-05, -4.683585211751051e-05, -2.083062645397149e-05, 6.46987246000208e-06, 3.372445280547254e-05, 5.958069232292473e-05, 8.274196443380788e-05, 0.00010203231795458123, 0.00011645606718957424, 0.00012524898920673877, 0.0001279185526072979, 0.00012427115871105343, 0.00011442462709965184, 9.880551078822464e-05, 7.813102274667472e-05, 5.337632683222182e-05, 2.572868106653914e-05, -3.4693239285843447e-06, -3.278485746704973e-05, -6.076505815144628e-05, -8.600891305832192e-05, -0.0001072373052011244, -0.00012335769133642316, -0.00013352013775147498, -0.00013716182729694992, -0.00013403799675870687, -0.000124236976262182, -0.00010817928705364466, -8.659987361170352e-05, -6.051486707292497e-05, -3.117380401818082e-05, 1.3907877743366992e-18, 3.1478415621677414e-05, 6.170327105792239e-05, 8.916335355024785e-05, 0.00011246991925872862, 0.00013042664795648307, 0.00014209102664608508, 0.0001468234258936718, 0.0001443219225620851, 0.00013464043149724603, 0.00011818948405561969, 9.571947884978727e-05, 6.828649929957464e-05, 3.7203048123046756e-05, 3.975342679041205e-06, -2.9769524189759977e-05, -6.236314948182553e-05, -9.217816841555759e-05, -0.00011770940909627825, -0.00013764969480689615, -0.00015095662092790008, -0.00015690679720137268, -0.00015513475227635354, -0.0001456545724067837, -0.00012886269541922957, -0.00010552201274549589, -7.672749052289873e-05, -4.385497959447093e-05, -8.495694601151627e-06, 2.7620719265541993e-05, 6.271061283769086e-05, 9.502435568720102e-05, 0.00012293335748836398, 0.00014501213445328176, 0.00016011072148103267, 0.0001674145896686241, 0.00016648795281071216, 0.00015729916049167514, 0.00014022596587892622, 0.00011604063183767721, 8.587543561588973e-05, 5.116981265018694e-05, 1.3601880709757097e-05, -2.499256152077578e-05, -6.270960147958249e-05, -9.767102164914832e-05, -0.00012811763735953718, -0.00015249777061399072, -0.000169546008692123, -0.00017834873870015144, -0.00017839267093222588, -0.0001695941318757832, -0.00015230700955726206, -0.00012730949674732983, -9.576932643540204e-05, -5.9189445892116055e-05, -1.9336666809977032e-05, 2.1843557988177054e-05, 6.232195300981402e-05, 0.00010008525714511052, 0.00013323627354111522, 0.00016008895181585103, 0.0001792539842426777, 0.00018971045210491866, 0.00019085983512923121, 0.0001825595390982926, 0.00016513421724084765, 0.00013936395407654345, 0.00010644969734130427, 6.795765511924401e-05, 2.5744888262124732e-05, -1.8130029275198467e-05, -6.150730769149959e-05, -0.00010223212302662432, -0.00013826142821926624, -0.00016776641132310033, -0.00018922501476481557, -0.00020150025375187397, -0.00020390011195559055, -0.00019621584215201437, -0.00017873682372737676, -0.00015224056551232934, -0.00011795876343967393, -7.752016972517595e-05, -3.28735877701547e-05, 1.3805974049319047e-05, 6.022304660291411e-05, 0.00010407443915028125, 0.00014316337183117867, 0.00017550933989696205, 0.00019944828818552196, 0.00021371796901803464, 0.0002175240806536749, 0.0002105838939314708, 0.00019314496603328735, 0.0001659773988649249, 0.00013034055882599205, 8.792493463261053e-05, 4.0772196371108294e-05, -8.822917152429e-06, -5.84240369789768e-05, -0.00010557276254985482, -0.00014791027933824807, -0.00018329524027649313, -0.00020991185738239437, -0.00022636281209997833, -0.00023174224770627916, -0.0002256850857520476, -0.00020838987256865948, -0.0001806140353437513, -0.0001436411839677021, -9.922225581249222e-05, -4.9492737161926925e-05, 3.129695414827438e-06, 5.6062581279547885e-05, 0.00010668523464119062, 0.00015246830298565328, 0.0001911000144900754, 0.00022060262563172728, 0.00023943348787724972, 0.0002465652651153505, 0.0002415414637653157, 0.00022450413962360471, 0.00019619199156295508, 0.00015790907491464168, 0.00011146506585646421, 5.9090085414936766e-05, 3.3277508464379935e-06, -5.308812978910282e-05, -0.00010736739204730839, -0.00015680136857554317, -0.00019889780378434807, -0.0002315063466085121, -0.00025292811915278435, -0.00026200388674624264, -0.0002581760345492512, -0.00024152187688741833, -0.00021275489416439086, -0.00017319517792202532, -0.00012470927322283387, -6.962225597817451e-05, -1.0606659998302348e-05, 4.944709871779196e-05, 0.0001075720283552073, 0.00016087102994788438, 0.00020666095952037722, 0.00024260768259409815, 0.00026684461045078933, 0.000278069288469851, 0.00027561295428313315, 0.00025947901303879917, 0.00023034874175209552, 0.00018955348059535027, 0.0001390140241710469, 8.115073433145881e-05, 1.8767763322102837e-05, -4.5082571887178347e-05, -0.00010724895400926471, -0.00016463641077280045, -0.00021436008682940155, -0.0002538902626838535, -0.00028118042973801494, -0.0002947732573375106, -0.0002938776451628655, -0.0002784135867841542, -0.00024902247241698205, -0.00020704120106529444, -0.00015444221207872033, -9.37408913159743e-05, -2.7875661544385366e-05, 3.993399877799675e-05, 0.00010634473437676206, 0.00016805394261609763, 0.00022196379723027349, 0.0002653365081641823, 0.0002959330449812114, 0.0003121283953078091, 0.0003129973483737558, 0.00029836632893420756, 0.0002688281238079071, 0.00022571953013539314, 0.00017106100858654827, 0.00010746251791715622, 3.7999285268597305e-05, -3.3936783438548446e-05, -0.00010480242053745314, -0.00017107732128351927, -0.00022943876683712006, -0.0002769279817584902, -0.0003110998368356377, -0.00033014826476573944, -0.00033300142968073487, -0.00031938086613081396, -0.000289821793558076, -0.00024565402418375015, -0.00018894228560384363, -0.00012239035277161747, -4.921241998090409e-05, 2.7021838832297362e-05, 0.00010256116365781054, 0.0001736570557113737, 0.00023674954718444496, 0.00028864521300420165, 0.0003266784187871963, 0.00034884794149547815, 0.0003539217577781528, 0.0003415044629946351, 0.000312063901219517, 0.00026691542007029057, 0.00020816356118302792, 0.00013860478065907955, 6.159433542052284e-05, -1.9115021132165566e-05, -9.955577115761116e-05, -0.00017574032244738191, -0.00024385850701946765, -0.000300467771012336, -0.00034266692819073796, -0.00036824436392635107, -0.00037579337367787957, -0.0003647887788247317, -0.0003356201050337404, -0.0002895802608691156, -0.000228808683459647, -0.0001561926765134558, -7.523057865910232e-05, 1.0136512173630763e-05, 9.571624104864895e-05, 0.0001772706164047122, 0.0002507256285753101, 0.00031237443909049034, 0.0003590641135815531, 0.0003883564786519855, 0.00039865486905910075, 0.0003892902168445289, 0.00036056223325431347, 0.0003137321618851274, 0.0002509687910787761, 0.00017524836584925652, 9.021380537888035e-05, -4.6256804257705425e-18, -9.096709982259199e-05, -0.00017818727064877748, -0.00025730833294801414, -0.00032434306922368705, -0.0003758697130251676, -0.0004092062881682068, -0.00042254949221387506, -0.00041507158312015235, -0.00038696930278092623, -0.0003394628583919257, -0.0002747438265942037, -0.0001958748180186376, -0.00010664497676771134, -1.1388235179765616e-05, 8.522671123500913e-05, 0.00017842501983977854, 0.0002635612909216434, 0.00033635087311267853, 0.0003930848906747997, 0.00043081905459985137, 0.0004475258756428957, 0.00044220240670256317, 0.00041492885793559253, 0.00036687339888885617, 0.0003002434968948364, 0.00021818502864334732, 0.00012463452003430575, 2.413046058791224e-05, -7.840633043088019e-05, -0.00017791337450034916, -0.00026943610282614827, -0.00034837418934330344, -0.0004107124113943428, -0.00045322440564632416, -0.00047363905468955636, -0.00047076091868802905, -0.0004445384838618338, -0.00039607621147297323, -0.00032758936868049204, -0.00024230372218880802, -0.00014430400915443897, -3.8338843296514824e-05, 7.040903437882662e-05, 0.00017657583521213382, 0.00027488087653182447, 0.0003603889199439436, 0.0004287575138732791, 0.0004764569166582078, 0.0005009517772123218, 0.000500835245475173, 0.0004759076691698283, 0.0004271967045497149, 0.00035691686207428575, 0.0002683693601284176, 0.00016578803479205817, 5.4137108236318454e-05, -6.112844857852906e-05, -0.00017432906315661967, -0.00027983999461866915, -0.00037237038486637175, -0.00044722817256115377, -0.0005005573621019721, -0.0005295362789183855, -0.0005325256497599185, -0.0005091600469313562, -0.00046037608990445733, -0.00038837763713672757, -0.00029653668752871454, -0.00018923645257018507, -7.166252180468291e-05, 5.0447124522179365e-05, 0.00017108177416957915, 0.00028425335767678916, 0.00038429329288192093, 0.0004661358252633363, 0.0005255740834400058, 0.000559475680347532, 0.0005659466842189431, 0.0005444360431283712, 0.0004957740311510861, 0.00042214285349473357, 0.00032697964343242347, 0.00021481722069438547, 9.106837387662381e-05, -3.8234553358051926e-05, -0.00016673329810146242, -0.0002880559186451137, -0.0003961321199312806, -0.0004854965372942388, -0.0005515645607374609, -0.0005908666644245386, -0.0006012299563735723, -0.000581896398216486, -0.0005335725145414472, -0.00045840672100894153, -0.0003598951443564147, -0.0002427198487566784, -0.00011252694093855098, 2.434480302326847e-05, 0.0001611720654182136, 0.0002911766932811588, 0.0004078609053976834, 0.0005053316126577556, 0.0005785970133729279, 0.0006238220958039165, 0.0006385278538800776, 0.0006217259215191007, 0.0005739799235016108, 0.0004973913310095668, 0.0003955075517296791, 0.0002731596177909523, 0.00013623324048239738, -8.613516911282204e-06, -0.00015427335165441036, -0.00029353785794228315, -0.00041945368866436183, -0.0005256690201349556, -0.0006067533977329731, -0.0006584744551219046, -0.000678017851896584, -0.000664138759020716, -0.0006172371795400977, -0.0005393519531935453, -0.00043407423072494566, -0.0003063828335143626, -0.0001624096039449796, -9.14580868993653e-06, 0.0001458967599319294, 0.0002950532943941653, 0.00043088404345326126, 0.0005465449648909271, 0.0006361316773109138, 0.0006949800299480557, 0.0007199075189419091, 0.0007093846215866506, 0.0006636236794292927, 0.0005845847190357745, 0.0004758928553201258, 0.00034267344744876027, 0.0001913115120260045, 2.9146469387342222e-05, -0.00013588306319434196, -0.0002956270473077893, -0.0004421257763169706, -0.000568005780223757, -0.0006668499554507434, -0.0007335240952670574, -0.0007644417928531766, -0.0007577562355436385, -0.000713466783054173, -0.0006334351492114365, -0.000521309906616807, -0.00038236123509705067, -0.00022323481971397996, -5.163443347555585e-05, 0.00012404986773617566, 0.00029515125788748264, 0.0004531526647042483, 0.0005901101394556463, 0.0006990510155446827, 0.0007743280148133636, 0.0008119108970277011, 0.0008095999946817756, 0.0007671521161682904, 0.0006863095331937075, 0.0005707319942303002, 0.000425832491600886, 0.00025852504768408835, 7.689587073400617e-05, -0.00011018651275662705, -0.0002935032534878701, -0.0004639385442715138, -0.0006129320245236158, -0.0007329074433073401, -0.0008176571573130786, -0.0008626613416709006, -0.0008653277764096856, -0.0008251374820247293, -0.0007436894229613245, -0.000624640379101038, -0.0004735433612950146, -0.0002975893148686737, -0.00010526673577260226, 9.404715819982812e-05, 0.0002905423170886934, 0.0004744576581288129, 0.0006365649751387537, 0.0007686304743401706, 0.0008638321305625141, 0.0009171100682578981, 0.0009254338219761848, 0.0008879714296199381, 0.0008061505504883826, 0.0006836095126345754, 0.0005260373582132161, 0.00034091173438355327, 0.00013714533997699618, -7.53419881220907e-05, -0.0002861048560589552, -0.0004846844240091741, -0.0006611263961531222, -0.000806478492449969, -0.0009132429258897901, -0.0009757621446624398, -0.0009905158076435328, -0.0009563157800585032, -0.0008743872167542577, -0.0007483310182578862, -0.0005839684163220227, -0.0003890737716574222, -0.00017300885519944131, 5.3725547331850976e-05, 0.0002799984940793365, 0.0004945938126184046, 0.0006867647171020508, 0.0008467703592032194, 0.0009663678938522935, 0.0010392351541668177, 0.0010613027261570096, 0.001030977233313024, 0.0009492445969954133, 0.0008196467533707619, 0.0006481313030235469, 0.0004427810781635344, 0.0002134351379936561, -2.8781170840375125e-05, -0.0002719939511734992, -0.0005041611730121076, -0.0007136673084460199, -0.0008899026433937252, -0.0010237981332466006, -0.001108290976844728, -0.0011386933038011193, -0.001112949219532311, -0.0010317628039047122, -0.0008985913009382784, -0.0007195024518296123, -0.0005028999876230955, -0.00025913238641805947, 6.649994457528183e-18, 0.00026181404246017337, 0.0005133626400493085, 0.0007420728215947747, 0.0009363722638227046, 0.0010862721828743815, 0.0011838792124763131, 0.0012238062918186188, 0.0012034679530188441, 0.0011232357937842607, 0.0009864522144198418, 0.0007992960745468736, 0.0005705069634132087, 0.0003109796380158514, 3.3247888495679945e-05, -0.0002491186314728111, -0.0005221748142503202, -0.0007722866139374673, -0.0009868089109659195, -0.00115472252946347, -0.001267197192646563, -0.001318052178248763, -0.0013040914200246334, -0.0012252941960468888, -0.0010848513338714838, -0.000889042392373085, -0.0006469582440331578, -0.000370083493180573, -7.175379141699523e-05, 0.0002334834134671837, 0.0005305754020810127, 0.0008047035080380738, 0.0010420193430036306, 0.00123034103307873, 0.001359775080345571, 0.0014232321409508586, 0.0014168096240609884, 0.0013400219613686204, 0.0011958626564592123, 0.0009906975319609046, 0.0007339878939092159, 0.0004378583689685911, 0.00011652784451143816, -0.00021436979295685887, -0.0005385427502915263, -0.0008398398058488965, -0.001103051588870585, -0.0013146739220246673, -0.0014635968254879117, -0.0015416829846799374, -0.001544205704703927, -0.001470124232582748, -0.0013221793342381716, -0.0011068042367696762, -0.0008338508778251708, -0.000516143802087754, -0.00016888270329218358, 0.00019108070409856737, 0.0005460561951622367, 0.0008783797966316342, 0.001171288313344121, 0.001409759745001793, 0.0015812789788469672, 0.0016764882020652294, 0.001689690281637013, 0.0016191770555451512, 0.0014673653058707714, 0.0012407297035679221, 0.000949535402469337, 0.0006073787808418274, 0.00023055872588884085, -0.00016269460320472717, -0.0005530961789190769, -0.00092124636285007, -0.001248588552698493, -0.0015183392679318786, -0.0017163412412628531, -0.0018317995127290487, -0.0018578609451651573, -0.0017920067766681314, -0.0016362359747290611, -0.0013970290310680866, -0.001085088704712689, -0.000714869995135814, -0.00030391637119464576, 0.00012796357623301446, 0.0005596443661488593, 0.0009697095374576747, 0.0013375068083405495, 0.0016441801562905312, 0.00187362777069211, 0.002013338962569833, 0.0020550640765577555, 0.0019952848087996244, 0.001835458679124713, 0.0015820191474631429, 0.0012461327714845538, 0.0008432171307504177, 0.00039224274223670363, -8.515059744240716e-05, -0.0005656833527609706, -0.001025561592541635, -0.0014416450867429376, -0.0017926020082086325, -0.0020599898416548967, -0.0022292137145996094, -0.002290307777002454, -0.0022385010961443186, -0.0020745364017784595, -0.001804722473025322, -0.0014407126000151038, -0.0009990152902901173, -0.0005002589896321297, 3.175938400090672e-05, 0.0005711971316486597, 0.0010914079612120986, 0.0015662448713555932, 0.0019713598303496838, 0.0022854364942759275, 0.0024912962689995766, 0.0025768170598894358, 0.0025356209371238947, 0.0023674897383898497, 0.002078484743833542, 0.0016807597130537033, 0.0011920711258426309, 0.0006350020412355661, 3.59369587386027e-05, -0.0005761710926890373, -0.0011711812112480402, -0.0017192293889820576, -0.002192207146435976, -0.0025651820469647646, -0.0028176873456686735, -0.0029348169919103384, -0.0029080715030431747, -0.0027359002269804478, -0.002423915546387434, -0.0019847608637064695, -0.0014376287581399083, -0.00080744648585096, -0.00012376694940030575, 0.0005805919063277543, 0.0012710957089439034, 0.001913158455863595, 0.00247384374961257, 0.00292352307587862, 0.0032374050933867693, 0.003396861720830202, 0.0033904805313795805, 0.0032147890888154507, 0.0028746011666953564, 0.0023829734418541193, 0.0017607474001124501, 0.0010357110295444727, 0.00024139281595125794, -0.0005844476982019842, -0.0014015737688168883, -0.0021691867150366306, -0.002847915282472968, -0.003401783062145114, -0.003800058737397194, -0.004018895328044891, -0.004042678512632847, -0.0038650003261864185, -0.003489220980554819, -0.002928559435531497, -0.0022057134192436934, -0.001352005871012807, -0.000406091712648049, 0.0005877281655557454, 0.0015815109945833683, 0.002525910036638379, 0.003372541395947337, 0.004076373763382435, 0.004598023369908333, 0.004905842710286379, 0.004977701231837273, 0.004802354611456394, 0.004380337428301573, 0.0037243138067424297, 0.0028588545974344015, 0.0018196417950093746, 0.0006521090981550515, -0.0005904243444092572, -0.001849060645326972, -0.0030619718600064516, -0.004167277365922928, -0.005106025841087103, -0.005825136788189411, -0.00628017308190465, -0.006437803152948618, -0.006277826149016619, -0.005794658791273832, -0.004998188931494951, -0.003913940396159887, -0.0025825095362961292, -0.0010582847753539681, 0.0005925290170125663, 0.0022945089731365442, 0.003966146614402533, 0.005523386411368847, 0.0068834321573376656, 0.0079686613753438, 0.008710469119250774, 0.009052888490259647, 0.008955799974501133, 0.008397581987082958, 0.0073770880699157715, 0.0059147970750927925, 0.004053107462823391, 0.001855697249993682, -0.0005940364208072424, -0.0031954331789165735, -0.005833843257278204, -0.008384611457586288, -0.010717632248997688, -0.012702303007245064, -0.014212685637176037, -0.015132686123251915, -0.015361011028289795, -0.01481575146317482, -0.01343833189457655, -0.011196720413863659, -0.008087699301540852, -0.004138120915740728, 0.0005949424812570214, 0.006025177892297506, 0.012039124965667725, 0.018499325960874557, 0.025248434394598007, 0.03211412951350212, 0.03891469165682793, 0.04546498507261276, 0.05158267915248871, 0.05709446594119072, 0.06184202432632446, 0.06568747013807297, 0.06851819157600403, 0.07025083154439926, 0.07083413004875183, 0.07025083154439926, 0.06851819157600403, 0.06568747013807297, 0.06184202432632446, 0.05709446594119072, 0.05158267915248871, 0.04546498507261276, 0.03891469165682793, 0.03211412951350212, 0.025248434394598007, 0.018499325960874557, 0.012039124965667725, 0.006025177892297506, 0.0005949424812570214, -0.004138120915740728, -0.008087699301540852, -0.011196720413863659, -0.01343833189457655, -0.01481575146317482, -0.015361011028289795, -0.015132686123251915, -0.014212685637176037, -0.012702303007245064, -0.010717632248997688, -0.008384611457586288, -0.005833843257278204, -0.0031954331789165735, -0.0005940364208072424, 0.001855697249993682, 0.004053107462823391, 0.0059147970750927925, 0.0073770880699157715, 0.008397581987082958, 0.008955799974501133, 0.009052888490259647, 0.008710469119250774, 0.0079686613753438, 0.0068834321573376656, 0.005523386411368847, 0.003966146614402533, 0.0022945089731365442, 0.0005925290170125663, -0.0010582847753539681, -0.0025825095362961292, -0.003913940396159887, -0.004998188931494951, -0.005794658791273832, -0.006277826149016619, -0.006437803152948618, -0.00628017308190465, -0.005825136788189411, -0.005106025841087103, -0.004167277365922928, -0.0030619718600064516, -0.001849060645326972, -0.0005904243444092572, 0.0006521090981550515, 0.0018196417950093746, 0.0028588545974344015, 0.0037243138067424297, 0.004380337428301573, 0.004802354611456394, 0.004977701231837273, 0.004905842710286379, 0.004598023369908333, 0.004076373763382435, 0.003372541395947337, 0.002525910036638379, 0.0015815109945833683, 0.0005877281655557454, -0.000406091712648049, -0.001352005871012807, -0.0022057134192436934, -0.002928559435531497, -0.003489220980554819, -0.0038650003261864185, -0.004042678512632847, -0.004018895328044891, -0.003800058737397194, -0.003401783062145114, -0.002847915282472968, -0.0021691867150366306, -0.0014015737688168883, -0.0005844476982019842, 0.00024139281595125794, 0.0010357110295444727, 0.0017607474001124501, 0.0023829734418541193, 0.0028746011666953564, 0.0032147890888154507, 0.0033904805313795805, 0.003396861720830202, 0.0032374050933867693, 0.00292352307587862, 0.00247384374961257, 0.001913158455863595, 0.0012710957089439034, 0.0005805919063277543, -0.00012376694940030575, -0.00080744648585096, -0.0014376287581399083, -0.0019847608637064695, -0.002423915546387434, -0.0027359002269804478, -0.0029080715030431747, -0.0029348169919103384, -0.0028176873456686735, -0.0025651820469647646, -0.002192207146435976, -0.0017192293889820576, -0.0011711812112480402, -0.0005761710926890373, 3.59369587386027e-05, 0.0006350020412355661, 0.0011920711258426309, 0.0016807597130537033, 0.002078484743833542, 0.0023674897383898497, 0.0025356209371238947, 0.0025768170598894358, 0.0024912962689995766, 0.0022854364942759275, 0.0019713598303496838, 0.0015662448713555932, 0.0010914079612120986, 0.0005711971316486597, 3.175938400090672e-05, -0.0005002589896321297, -0.0009990152902901173, -0.0014407126000151038, -0.001804722473025322, -0.0020745364017784595, -0.0022385010961443186, -0.002290307777002454, -0.0022292137145996094, -0.0020599898416548967, -0.0017926020082086325, -0.0014416450867429376, -0.001025561592541635, -0.0005656833527609706, -8.515059744240716e-05, 0.00039224274223670363, 0.0008432171307504177, 0.0012461327714845538, 0.0015820191474631429, 0.001835458679124713, 0.0019952848087996244, 0.0020550640765577555, 0.002013338962569833, 0.00187362777069211, 0.0016441801562905312, 0.0013375068083405495, 0.0009697095374576747, 0.0005596443661488593, 0.00012796357623301446, -0.00030391637119464576, -0.000714869995135814, -0.001085088704712689, -0.0013970290310680866, -0.0016362359747290611, -0.0017920067766681314, -0.0018578609451651573, -0.0018317995127290487, -0.0017163412412628531, -0.0015183392679318786, -0.001248588552698493, -0.00092124636285007, -0.0005530961789190769, -0.00016269460320472717, 0.00023055872588884085, 0.0006073787808418274, 0.000949535402469337, 0.0012407297035679221, 0.0014673653058707714, 0.0016191770555451512, 0.001689690281637013, 0.0016764882020652294, 0.0015812789788469672, 0.001409759745001793, 0.001171288313344121, 0.0008783797966316342, 0.0005460561951622367, 0.00019108070409856737, -0.00016888270329218358, -0.000516143802087754, -0.0008338508778251708, -0.0011068042367696762, -0.0013221793342381716, -0.001470124232582748, -0.001544205704703927, -0.0015416829846799374, -0.0014635968254879117, -0.0013146739220246673, -0.001103051588870585, -0.0008398398058488965, -0.0005385427502915263, -0.00021436979295685887, 0.00011652784451143816, 0.0004378583689685911, 0.0007339878939092159, 0.0009906975319609046, 0.0011958626564592123, 0.0013400219613686204, 0.0014168096240609884, 0.0014232321409508586, 0.001359775080345571, 0.00123034103307873, 0.0010420193430036306, 0.0008047035080380738, 0.0005305754020810127, 0.0002334834134671837, -7.175379141699523e-05, -0.000370083493180573, -0.0006469582440331578, -0.000889042392373085, -0.0010848513338714838, -0.0012252941960468888, -0.0013040914200246334, -0.001318052178248763, -0.001267197192646563, -0.00115472252946347, -0.0009868089109659195, -0.0007722866139374673, -0.0005221748142503202, -0.0002491186314728111, 3.3247888495679945e-05, 0.0003109796380158514, 0.0005705069634132087, 0.0007992960745468736, 0.0009864522144198418, 0.0011232357937842607, 0.0012034679530188441, 0.0012238062918186188, 0.0011838792124763131, 0.0010862721828743815, 0.0009363722638227046, 0.0007420728215947747, 0.0005133626400493085, 0.00026181404246017337, 6.649994457528183e-18, -0.00025913238641805947, -0.0005028999876230955, -0.0007195024518296123, -0.0008985913009382784, -0.0010317628039047122, -0.001112949219532311, -0.0011386933038011193, -0.001108290976844728, -0.0010237981332466006, -0.0008899026433937252, -0.0007136673084460199, -0.0005041611730121076, -0.0002719939511734992, -2.8781170840375125e-05, 0.0002134351379936561, 0.0004427810781635344, 0.0006481313030235469, 0.0008196467533707619, 0.0009492445969954133, 0.001030977233313024, 0.0010613027261570096, 0.0010392351541668177, 0.0009663678938522935, 0.0008467703592032194, 0.0006867647171020508, 0.0004945938126184046, 0.0002799984940793365, 5.3725547331850976e-05, -0.00017300885519944131, -0.0003890737716574222, -0.0005839684163220227, -0.0007483310182578862, -0.0008743872167542577, -0.0009563157800585032, -0.0009905158076435328, -0.0009757621446624398, -0.0009132429258897901, -0.000806478492449969, -0.0006611263961531222, -0.0004846844240091741, -0.0002861048560589552, -7.53419881220907e-05, 0.00013714533997699618, 0.00034091173438355327, 0.0005260373582132161, 0.0006836095126345754, 0.0008061505504883826, 0.0008879714296199381, 0.0009254338219761848, 0.0009171100682578981, 0.0008638321305625141, 0.0007686304743401706, 0.0006365649751387537, 0.0004744576581288129, 0.0002905423170886934, 9.404715819982812e-05, -0.00010526673577260226, -0.0002975893148686737, -0.0004735433612950146, -0.000624640379101038, -0.0007436894229613245, -0.0008251374820247293, -0.0008653277764096856, -0.0008626613416709006, -0.0008176571573130786, -0.0007329074433073401, -0.0006129320245236158, -0.0004639385442715138, -0.0002935032534878701, -0.00011018651275662705, 7.689587073400617e-05, 0.00025852504768408835, 0.000425832491600886, 0.0005707319942303002, 0.0006863095331937075, 0.0007671521161682904, 0.0008095999946817756, 0.0008119108970277011, 0.0007743280148133636, 0.0006990510155446827, 0.0005901101394556463, 0.0004531526647042483, 0.00029515125788748264, 0.00012404986773617566, -5.163443347555585e-05, -0.00022323481971397996, -0.00038236123509705067, -0.000521309906616807, -0.0006334351492114365, -0.000713466783054173, -0.0007577562355436385, -0.0007644417928531766, -0.0007335240952670574, -0.0006668499554507434, -0.000568005780223757, -0.0004421257763169706, -0.0002956270473077893, -0.00013588306319434196, 2.9146469387342222e-05, 0.0001913115120260045, 0.00034267344744876027, 0.0004758928553201258, 0.0005845847190357745, 0.0006636236794292927, 0.0007093846215866506, 0.0007199075189419091, 0.0006949800299480557, 0.0006361316773109138, 0.0005465449648909271, 0.00043088404345326126, 0.0002950532943941653, 0.0001458967599319294, -9.14580868993653e-06, -0.0001624096039449796, -0.0003063828335143626, -0.00043407423072494566, -0.0005393519531935453, -0.0006172371795400977, -0.000664138759020716, -0.000678017851896584, -0.0006584744551219046, -0.0006067533977329731, -0.0005256690201349556, -0.00041945368866436183, -0.00029353785794228315, -0.00015427335165441036, -8.613516911282204e-06, 0.00013623324048239738, 0.0002731596177909523, 0.0003955075517296791, 0.0004973913310095668, 0.0005739799235016108, 0.0006217259215191007, 0.0006385278538800776, 0.0006238220958039165, 0.0005785970133729279, 0.0005053316126577556, 0.0004078609053976834, 0.0002911766932811588, 0.0001611720654182136, 2.434480302326847e-05, -0.00011252694093855098, -0.0002427198487566784, -0.0003598951443564147, -0.00045840672100894153, -0.0005335725145414472, -0.000581896398216486, -0.0006012299563735723, -0.0005908666644245386, -0.0005515645607374609, -0.0004854965372942388, -0.0003961321199312806, -0.0002880559186451137, -0.00016673329810146242, -3.8234553358051926e-05, 9.106837387662381e-05, 0.00021481722069438547, 0.00032697964343242347, 0.00042214285349473357, 0.0004957740311510861, 0.0005444360431283712, 0.0005659466842189431, 0.000559475680347532, 0.0005255740834400058, 0.0004661358252633363, 0.00038429329288192093, 0.00028425335767678916, 0.00017108177416957915, 5.0447124522179365e-05, -7.166252180468291e-05, -0.00018923645257018507, -0.00029653668752871454, -0.00038837763713672757, -0.00046037608990445733, -0.0005091600469313562, -0.0005325256497599185, -0.0005295362789183855, -0.0005005573621019721, -0.00044722817256115377, -0.00037237038486637175, -0.00027983999461866915, -0.00017432906315661967, -6.112844857852906e-05, 5.4137108236318454e-05, 0.00016578803479205817, 0.0002683693601284176, 0.00035691686207428575, 0.0004271967045497149, 0.0004759076691698283, 0.000500835245475173, 0.0005009517772123218, 0.0004764569166582078, 0.0004287575138732791, 0.0003603889199439436, 0.00027488087653182447, 0.00017657583521213382, 7.040903437882662e-05, -3.8338843296514824e-05, -0.00014430400915443897, -0.00024230372218880802, -0.00032758936868049204, -0.00039607621147297323, -0.0004445384838618338, -0.00047076091868802905, -0.00047363905468955636, -0.00045322440564632416, -0.0004107124113943428, -0.00034837418934330344, -0.00026943610282614827, -0.00017791337450034916, -7.840633043088019e-05, 2.413046058791224e-05, 0.00012463452003430575, 0.00021818502864334732, 0.0003002434968948364, 0.00036687339888885617, 0.00041492885793559253, 0.00044220240670256317, 0.0004475258756428957, 0.00043081905459985137, 0.0003930848906747997, 0.00033635087311267853, 0.0002635612909216434, 0.00017842501983977854, 8.522671123500913e-05, -1.1388235179765616e-05, -0.00010664497676771134, -0.0001958748180186376, -0.0002747438265942037, -0.0003394628583919257, -0.00038696930278092623, -0.00041507158312015235, -0.00042254949221387506, -0.0004092062881682068, -0.0003758697130251676, -0.00032434306922368705, -0.00025730833294801414, -0.00017818727064877748, -9.096709982259199e-05, -4.6256804257705425e-18, 9.021380537888035e-05, 0.00017524836584925652, 0.0002509687910787761, 0.0003137321618851274, 0.00036056223325431347, 0.0003892902168445289, 0.00039865486905910075, 0.0003883564786519855, 0.0003590641135815531, 0.00031237443909049034, 0.0002507256285753101, 0.0001772706164047122, 9.571624104864895e-05, 1.0136512173630763e-05, -7.523057865910232e-05, -0.0001561926765134558, -0.000228808683459647, -0.0002895802608691156, -0.0003356201050337404, -0.0003647887788247317, -0.00037579337367787957, -0.00036824436392635107, -0.00034266692819073796, -0.000300467771012336, -0.00024385850701946765, -0.00017574032244738191, -9.955577115761116e-05, -1.9115021132165566e-05, 6.159433542052284e-05, 0.00013860478065907955, 0.00020816356118302792, 0.00026691542007029057, 0.000312063901219517, 0.0003415044629946351, 0.0003539217577781528, 0.00034884794149547815, 0.0003266784187871963, 0.00028864521300420165, 0.00023674954718444496, 0.0001736570557113737, 0.00010256116365781054, 2.7021838832297362e-05, -4.921241998090409e-05, -0.00012239035277161747, -0.00018894228560384363, -0.00024565402418375015, -0.000289821793558076, -0.00031938086613081396, -0.00033300142968073487, -0.00033014826476573944, -0.0003110998368356377, -0.0002769279817584902, -0.00022943876683712006, -0.00017107732128351927, -0.00010480242053745314, -3.3936783438548446e-05, 3.7999285268597305e-05, 0.00010746251791715622, 0.00017106100858654827, 0.00022571953013539314, 0.0002688281238079071, 0.00029836632893420756, 0.0003129973483737558, 0.0003121283953078091, 0.0002959330449812114, 0.0002653365081641823, 0.00022196379723027349, 0.00016805394261609763, 0.00010634473437676206, 3.993399877799675e-05, -2.7875661544385366e-05, -9.37408913159743e-05, -0.00015444221207872033, -0.00020704120106529444, -0.00024902247241698205, -0.0002784135867841542, -0.0002938776451628655, -0.0002947732573375106, -0.00028118042973801494, -0.0002538902626838535, -0.00021436008682940155, -0.00016463641077280045, -0.00010724895400926471, -4.5082571887178347e-05, 1.8767763322102837e-05, 8.115073433145881e-05, 0.0001390140241710469, 0.00018955348059535027, 0.00023034874175209552, 0.00025947901303879917, 0.00027561295428313315, 0.000278069288469851, 0.00026684461045078933, 0.00024260768259409815, 0.00020666095952037722, 0.00016087102994788438, 0.0001075720283552073, 4.944709871779196e-05, -1.0606659998302348e-05, -6.962225597817451e-05, -0.00012470927322283387, -0.00017319517792202532, -0.00021275489416439086, -0.00024152187688741833, -0.0002581760345492512, -0.00026200388674624264, -0.00025292811915278435, -0.0002315063466085121, -0.00019889780378434807, -0.00015680136857554317, -0.00010736739204730839, -5.308812978910282e-05, 3.3277508464379935e-06, 5.9090085414936766e-05, 0.00011146506585646421, 0.00015790907491464168, 0.00019619199156295508, 0.00022450413962360471, 0.0002415414637653157, 0.0002465652651153505, 0.00023943348787724972, 0.00022060262563172728, 0.0001911000144900754, 0.00015246830298565328, 0.00010668523464119062, 5.6062581279547885e-05, 3.129695414827438e-06, -4.9492737161926925e-05, -9.922225581249222e-05, -0.0001436411839677021, -0.0001806140353437513, -0.00020838987256865948, -0.0002256850857520476, -0.00023174224770627916, -0.00022636281209997833, -0.00020991185738239437, -0.00018329524027649313, -0.00014791027933824807, -0.00010557276254985482, -5.84240369789768e-05, -8.822917152429e-06, 4.0772196371108294e-05, 8.792493463261053e-05, 0.00013034055882599205, 0.0001659773988649249, 0.00019314496603328735, 0.0002105838939314708, 0.0002175240806536749, 0.00021371796901803464, 0.00019944828818552196, 0.00017550933989696205, 0.00014316337183117867, 0.00010407443915028125, 6.022304660291411e-05, 1.3805974049319047e-05, -3.28735877701547e-05, -7.752016972517595e-05, -0.00011795876343967393, -0.00015224056551232934, -0.00017873682372737676, -0.00019621584215201437, -0.00020390011195559055, -0.00020150025375187397, -0.00018922501476481557, -0.00016776641132310033, -0.00013826142821926624, -0.00010223212302662432, -6.150730769149959e-05, -1.8130029275198467e-05, 2.5744888262124732e-05, 6.795765511924401e-05, 0.00010644969734130427, 0.00013936395407654345, 0.00016513421724084765, 0.0001825595390982926, 0.00019085983512923121, 0.00018971045210491866, 0.0001792539842426777, 0.00016008895181585103, 0.00013323627354111522, 0.00010008525714511052, 6.232195300981402e-05, 2.1843557988177054e-05, -1.9336666809977032e-05, -5.9189445892116055e-05, -9.576932643540204e-05, -0.00012730949674732983, -0.00015230700955726206, -0.0001695941318757832, -0.00017839267093222588, -0.00017834873870015144, -0.000169546008692123, -0.00015249777061399072, -0.00012811763735953718, -9.767102164914832e-05, -6.270960147958249e-05, -2.499256152077578e-05, 1.3601880709757097e-05, 5.116981265018694e-05, 8.587543561588973e-05, 0.00011604063183767721, 0.00014022596587892622, 0.00015729916049167514, 0.00016648795281071216, 0.0001674145896686241, 0.00016011072148103267, 0.00014501213445328176, 0.00012293335748836398, 9.502435568720102e-05, 6.271061283769086e-05, 2.7620719265541993e-05, -8.495694601151627e-06, -4.385497959447093e-05, -7.672749052289873e-05, -0.00010552201274549589, -0.00012886269541922957, -0.0001456545724067837, -0.00015513475227635354, -0.00015690679720137268, -0.00015095662092790008, -0.00013764969480689615, -0.00011770940909627825, -9.217816841555759e-05, -6.236314948182553e-05, -2.9769524189759977e-05, 3.975342679041205e-06, 3.7203048123046756e-05, 6.828649929957464e-05, 9.571947884978727e-05, 0.00011818948405561969, 0.00013464043149724603, 0.0001443219225620851, 0.0001468234258936718, 0.00014209102664608508, 0.00013042664795648307, 0.00011246991925872862, 8.916335355024785e-05, 6.170327105792239e-05, 3.1478415621677414e-05, 1.3907877743366992e-18, -3.117380401818082e-05, -6.051486707292497e-05, -8.659987361170352e-05, -0.00010817928705364466, -0.000124236976262182, -0.00013403799675870687, -0.00013716182729694992, -0.00013352013775147498, -0.00012335769133642316, -0.0001072373052011244, -8.600891305832192e-05, -6.076505815144628e-05, -3.278485746704973e-05, -3.4693239285843447e-06, 2.572868106653914e-05, 5.337632683222182e-05, 7.813102274667472e-05, 9.880551078822464e-05, 0.00011442462709965184, 0.00012427115871105343, 0.0001279185526072979, 0.00012524898920673877, 0.00011645606718957424, 0.00010203231795458123, 8.274196443380788e-05, 5.958069232292473e-05, 3.372445280547254e-05, 6.46987246000208e-06, -2.083062645397149e-05, -4.683585211751051e-05, -7.028163236100227e-05, -9.00421291589737e-05, -0.00010518378985580057, -0.0001150093085016124, -0.00011908944725291803, -0.00011728156096069142, -0.00010973360622301698, -9.68740350799635e-05, -7.938786438899115e-05, -5.8180507039651275e-05, -3.433098390814848e-05, -9.03721411305014e-06, 1.6444055290776305e-05, 4.085959153599106e-05, 6.302123074419796e-05, 8.18635307950899e-05, 9.649497224017978e-05, 0.00010623990237945691, 0.00011066957813454792, 0.00010962071246467531, 0.00010320076398784295, 9.177993342746049e-05, 7.597025251016021e-05, 5.659306043526158e-05, 3.463651592028327e-05, 1.1205309419892728e-05, -1.2534786947071552e-05, -3.541481783031486e-05, -5.632012471323833e-05, -7.424454088322818e-05, -8.83386965142563e-05, -9.795014193514362e-05, -0.00010265334276482463, -0.00010226826998405159, -9.686667908681557e-05, -8.676598372403532e-05, -7.251106580952182e-05, -5.484518624143675e-05, -3.467142232693732e-05, -1.3006559129280504e-05, 9.069990483112633e-06, 3.0469889679807238e-05, 5.014944326831028e-05, 6.716039206366986e-05, 8.069552131928504e-05, 9.012679947772995e-05, 9.503438195679337e-05, 9.52250265982002e-05, 9.073920227820054e-05, 8.184662874555215e-05, 6.903062603669241e-05, 5.2962059271521866e-05, 3.4464450436644256e-05, 1.4471857866737992e-05, -6.018156000209274e-06, -2.599422623461578e-05, -4.448100662557408e-05, -6.058671715436503e-05, -7.354602712439373e-05, -8.275635627796873e-05, -8.780568168731406e-05, -8.849076402839273e-05, -8.482490375172347e-05, -7.703489973209798e-05, -6.554771243827417e-05, -5.096722816233523e-05, -3.4042761399177834e-05, -1.5630626876372844e-05, 3.349057124069077e-06, 2.1958279830869287e-05, 3.92874026147183e-05, 5.449953823699616e-05, 6.687087443424389e-05, 7.582499529235065e-05, 8.095960220089182e-05, 8.206436177715659e-05, 7.912916771601886e-05, 7.234239456010982e-05, 6.207953992998227e-05, 4.888266994385049e-05, 3.34319774992764e-05, 1.6510857676621526e-05, -1.033721559906553e-06, -1.833352325775195e-05, -3.4541932109277695e-05, -4.887529939878732e-05, -6.065074558136985e-05, -6.931859388714656e-05, -7.44878634577617e-05, -7.594375347252935e-05, -7.365621422650293e-05, -6.777937232982367e-05, -5.864188278792426e-05, -4.672884097089991e-05, -3.265621853643097e-05, -1.7139131159638055e-05, -9.555861879562144e-07, 1.5092430658114608e-05, 3.021862721652724e-05, 4.369084854261018e-05, 5.4866432037670165e-05, 6.322276021819562e-05, 6.838160334154963e-05, 7.012601417955011e-05, 6.840917194494978e-05, 6.33547970210202e-05, 5.5249056458706036e-05, 4.452470238902606e-05, 3.1738138204673305e-05, 1.7540660337544978e-05, 2.6453863029018976e-06, -1.220847752847476e-05, -2.629225309647154e-05, -3.892346649081446e-05, -4.949882713845e-05, -5.7522956922184676e-05, -6.2631479522679e-05, -6.460740405600518e-05, -6.339007813949138e-05, -5.9076362958876416e-05, -5.191401214688085e-05, -4.228778925607912e-05, -3.069896047236398e-05, -1.773930671333801e-05, -4.061001163790934e-06, 9.656127076596022e-06, 2.2738311599823646e-05, 3.455087426118553e-05, 4.452894791029394e-05, 5.220438106334768e-05, 5.7227607612730935e-05, 5.9383433836046606e-05, 5.859998782398179e-05, 5.49505784874782e-05, 4.864836228080094e-05, 4.0034225094132125e-05, 2.955851778096985e-05, 1.7757613022695296e-05, 5.226567736826837e-06, -7.410833404719597e-06, -1.9533046724973246e-05, -3.0551273084711283e-05, -3.9937993278726935e-05, -4.7252135118469596e-05, -5.215968849370256e-05, -5.444886483019218e-05, -5.403895920608193e-05, -5.098278052173555e-05, -4.546243144432083e-05, -3.777878373512067e-05, -2.8335274691926315e-05, -1.7616826880839653e-05, -6.165055310702883e-06, 5.449036507343408e-06, 1.6653457350912504e-05, 2.6903333491645753e-05, 3.570735134417191e-05, 4.265120151103474e-05, 4.741702650790103e-05, 4.9797807150753215e-05, 4.970617010258138e-05, 4.7177232772810385e-05, 4.2365318222437054e-05, 3.55349293386098e-05, 2.704638427530881e-05, 1.733692261041142e-05, 6.89827584210434e-06, -3.748159315364319e-06, -1.4077308151172474e-05, -2.3586248062201776e-05, -3.1818632123759016e-05, -3.8386515370802954e-05, -4.2988565837731585e-05, -4.542374881566502e-05, -4.5599957957165316e-05, -4.3537136662052944e-05, -3.9364917029161006e-05, -3.331484549562447e-05, -2.5707699023769237e-05, -1.6936624888330698e-05, -7.446901236107806e-06, 2.28660746870446e-06, 1.1783139598264825e-05, 2.057973324554041e-05, 2.8253718483028933e-05, 3.4442986361682415e-05, 3.8862970541231334e-05, 4.131963214604184e-05, 4.1717838030308485e-05, 4.0064711356535554e-05, 3.6468009056989104e-05, 3.1129500712268054e-05, 2.4333823603228666e-05, 1.643344876356423e-05, 7.830474714864977e-06, -1.0437665878271218e-06, -9.750277968123555e-06, -1.7864056644611992e-05, -2.499478250683751e-05, -3.080553869949654e-05, -3.502863910398446e-05, -3.74778792320285e-05, -3.8056601624703035e-05, -3.676124106277712e-05, -3.368028410477564e-05, -2.8988690246478654e-05, -2.2938149413676e-05, -1.5843706933083013e-05, -8.067427188507281e-06, -8.183177858798283e-19, 7.958842616062611e-06, 1.54200733959442e-05, 2.2024330974090844e-05, 2.7459172997623682e-05, 3.147378811263479e-05, 3.3890464692376554e-05, 3.461236337898299e-05, 3.362712959642522e-05, 3.1006387871457264e-05, 2.6901067030848935e-05, 2.1532890968956053e-05, 1.518255339760799e-05, 8.175096809281968e-06, 8.63355865021731e-07, -6.38975916444906e-06, -1.3229222531663254e-05, -1.9325219909660518e-05, -2.4388995370827615e-05, -2.8186470444779843e-05, -3.0548970244126394e-05, -3.138060128549114e-05, -3.066196586587466e-05, -2.8450016543501988e-05, -2.4874205337255262e-05, -2.0129120457568206e-05, -1.4464001651504077e-05, -8.169738975993823e-06, -1.5639967614333727e-06, 5.024763595429249e-06, 1.1273565178271383e-05, 1.688070551608689e-05, 2.1580261091003194e-05, 2.5154649847536348e-05, 2.7444617444416508e-05, 2.8356236725812778e-05, 2.7864569347002544e-05, 2.601392043288797e-05, 2.291464807058219e-05, 1.873681685538031e-05, 1.3700967429031152e-05, 8.066555892582983e-06, 2.1186572212172905e-06, -3.846408617391717e-06, -9.53579456108855e-06, -1.4674459634989034e-05, -1.9018409147975035e-05, -2.236623186036013e-05, -2.4568362277932465e-05, -2.553366357460618e-05, -2.5233048290829174e-05, -2.369998583162669e-05, -2.102794860547874e-05, -1.7364909581374377e-05, -1.2905288713227492e-05, -7.87970839155605e-06, -2.543119990150444e-06, 2.8380684398143785e-06, 7.999254194146488e-06, 1.2690607036347501e-05, 1.6689109543222003e-05, 1.9809116565738805e-05, 2.1910902432864532e-05, 2.2906828235136345e-05, 2.2764859750168398e-05, 2.150929685740266e-05, 1.92187144421041e-05, 1.6021298506530002e-05, 1.208776575367665e-05, 7.6223432188271545e-06, 2.852226771210553e-06, -1.983939682759228e-06, -6.64795197735657e-06, -1.0913742698903661e-05, -1.4578290574718267e-05, -1.747124406392686e-05, -1.946276461239904e-05, -2.0469278751988895e-05, -2.0456875063246116e-05, -1.944216273841448e-05, -1.7490687241661362e-05, -1.4712933989358135e-05, -1.1258193808316719e-05, -7.306618954316946e-06, -3.059888285861234e-06, 1.2690413768723374e-06, 5.466570655698888e-06, 9.32896182348486e-06, 1.2672181583184283e-05, 1.5340629033744335e-05, 1.7214324543601833e-05, 1.8214215742773376e-05, 1.8305418052477762e-05, 1.7498199667898007e-05, 1.5846755559323356e-05, 1.34458305183216e-05, 1.0425402251712512e-05, 6.943726475583389e-06, 3.1791037145012524e-06, -6.79212178056332e-07, -4.4404819163901266e-06, -7.921878932393156e-06, -1.0957334779959638e-05, -1.3405420759227127e-05, -1.5155882465478498e-05, -1.613453969184775e-05, -1.6306328689097427e-05, -1.5676367183914408e-05, -1.4289034879766405e-05, -1.222512946696952e-05, -9.597290045348927e-06, -6.5439230638730805e-06, -3.2219727472693194e-06, 2.0110621790081495e-07, 3.5557497994886944e-06, 6.678649697278161e-06, 9.42066890274873e-06, 1.1653921319521032e-05, 1.3277694051794242e-05, 1.4222919162421022e-05, 1.445502584829228e-05, 1.3975037290947512e-05, 1.2818905815947801e-05, 1.1055138202209491e-05, 8.780863026913721e-06, 6.11655605098349e-06, 3.1997171845432604e-06, 1.7781452754661586e-07, -2.7991354727419093e-06, -5.585981853073463e-06, -8.0494819485466e-06, -1.0074636520585045e-05, -1.157001588580897e-05, -1.2471822628867812e-05, -1.2746539141517133e-05, -1.2392028111207765e-05, -1.1437066859798506e-05, -9.93937919702148e-06, -7.982276656548493e-06, -5.6700987443036865e-06, -3.1227009458234534e-06, -4.6928943220336805e-07, 2.158102915927884e-06, 4.631153387890663e-06, 6.831486643932294e-06, 8.656304999021813e-06, 1.0023149116022978e-05, 1.087358032236807e-05, 1.1175587133038789e-05, 1.0924682101176586e-05, 1.0143590770894662e-05, 8.880638233677018e-06, 7.206877853604965e-06, 5.2121790758974385e-06, 3.0004514428583207e-06, 6.842709012744308e-07, -1.6208155102503952e-06, -3.8020255033188732e-06, -5.754829544457607e-06, -7.387930509139551e-06, -8.627490387880243e-06, -9.420424248673953e-06, -9.736605534271803e-06, -9.569893336447421e-06, -8.93797096068738e-06, -7.881008059484884e-06, -6.459241376433056e-06, -4.749618710775394e-06, -2.8416864097380312e-06, -8.329383263117052e-07, 1.1761350151573424e-06, 3.0870455702824984e-06, 4.808108769793762e-06, 6.258811936277198e-06, 7.373547759925714e-06, 8.104535481834318e-06, 8.42380632093409e-06, 8.324175723828375e-06, 7.819173333700746e-06, 6.941942046978511e-06, 5.743218025600072e-06, 4.288461695978185e-06, 2.6543375497567467e-06, 9.247138450518833e-07, -8.13615827155445e-07, -2.4752587250986835e-06, -3.980392648372799e-06, -5.258572855382226e-06, -6.251998001971515e-06, -6.9180837272142526e-06, -7.231227300508181e-06, -7.183709385572001e-06, -6.7856844907510094e-06, -6.064296030672267e-06, -5.061973752162885e-06, -3.834014023595955e-06, -2.445581003485131e-06, -9.682810286903987e-07, 5.234977606960456e-07, 1.956307414729963e-06, 3.2612329050607514e-06, 4.377180175652029e-06, 5.253707058727741e-06, 5.853268248756649e-06, 6.152769856271334e-06, 6.144379312900128e-06, 5.835563570144586e-06, 5.248376055533299e-06, 4.418033768160967e-06, 3.390883193787886e-06, 2.221864406237728e-06, 9.716046633911901e-07, -2.9669553214262123e-07, -1.520434580015717e-06, -2.6406769393361174e-06, -3.6049675600224873e-06, -4.369762336864369e-06, -4.902358796243789e-06, -5.182248060009442e-06, -5.201832209422719e-06, -4.9664881771605e-06, -4.493989763432182e-06, -3.8133268844831036e-06, -2.96301050184411e-06, -1.9889384930138476e-06, -9.419523507858685e-07, 1.2478736266530177e-07, 1.1584795629460132e-06, 2.1092746465001255e-06, 2.932656343546114e-06, 3.5915018088417128e-06, 4.057724254380446e-06, 4.313424597057747e-06, 4.351517873146804e-06, 4.175801677774871e-06, 3.8004861835361226e-06, 3.249227802371024e-06, 2.5537140118103707e-06, 1.751888817125291e-06, 8.859187232701515e-07, 2.7149318168432e-20, -8.618755487077578e-07, -1.658085693634348e-06, -2.3513671294494998e-06, -2.910537887146347e-06, -3.3118687952082837e-06, -3.540053739925497e-06, -3.5887314879801124e-06, -3.4605543532961747e-06, -3.166805072396528e-06, -2.726600541791413e-06, -2.1657247089024168e-06, -1.515168492005614e-06, -8.094500003608118e-07, -8.480726876314293e-08, 6.226417781363125e-07, 1.2786815659637796e-06, 1.8526350231695687e-06, 2.318777433174546e-06, 2.6574625735520385e-06, 2.8559143174788915e-06, 2.9086543236189755e-06, 2.8175543320685392e-06, 2.591520569694694e-06, 2.245840050818515e-06, 1.8012269720202312e-06, 1.2826316151404171e-06, 7.178708756327978e-07, 1.3616090654977597e-07, -4.333746801421512e-07, -9.631465900383773e-07, -1.42841849992692e-06, -1.8084441535393125e-06, -2.087366056002793e-06, -2.254845639981795e-06, -2.3063942080625566e-06, -2.2434035145124653e-06, -2.072881898129708e-06, -1.8069151792587945e-06, -1.4618976820202079e-06, -1.0575678288660129e-06, -6.159121426208003e-07, -1.5999307834135834e-07, 2.872369861961488e-07, 7.040755463094683e-07, 1.071107249117631e-06, 1.3720911056225304e-06]</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>channel_center</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>channel_center</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-channel_center</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_1_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-channel_center</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>label</key><value>Audio Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>complex_x_switch</key>
<param><key>id</key><value>complex_x_switch_0</value></param>
<param><key>switch_parameter_0</key><value>0 if mod_mode_param == "LSB" else 1</value></param>
</block>
<block>
<key>complex_x_switch</key>
<param><key>id</key><value>complex_x_switch_0_0</value></param>
<param><key>switch_parameter_0</key><value>0 if mod_mode_param == "LSB" else 1</value></param>
</block>
<block>
<key>complex_x_switch</key>
<param><key>id</key><value>complex_x_switch_0_0_0</value></param>
<param><key>switch_parameter_0</key><value>0 if mod_mode_param == "LSB" else 1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_lpf</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_lpf</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mod_mode_param</value></param>
<param><key>label</key><value>modulation_mode</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"None"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Weaver Modulator LSB</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>complex_x_switch_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>complex_x_switch_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_1_0</source_block_id><sink_block_id>complex_x_switch_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_1_1_0</source_block_id><sink_block_id>complex_x_switch_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>complex_x_switch_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>complex_x_switch_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>complex_x_switch_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>complex_x_switch_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>complex_x_switch_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>complex_x_switch_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>complex_x_switch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>complex_x_switch_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
